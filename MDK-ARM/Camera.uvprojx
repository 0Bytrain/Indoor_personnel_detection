# Keil uVision project Camera.uvprojx, settings and files
target Camera (6190000::V6.19::ARMCLANG)
  device: STM32H743VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x807FFFF) IROM2(0x8100000-0x817FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Camera +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../MDK-ARM;../Middlewares/ST/AI/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;./X-CUBE-AI/App;./X-CUBE-AI;../X-CUBE-AI/App;../X-CUBE-AI;Middlewares/ST/AI/Inc;X-CUBE-AI/App;../Middlewares/ST/AI/Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT6: RAM 0x30000000 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ./: mc2640.c mc2640.h mc2640_cfg.h mc2640_sccb.c mc2640_sccb.h demo.c demo.h malloc.c malloc.h WIFI.c WIFI.h wate_mode.c wait_mode.h
    ../Core/Src/: main.c gpio.c dcmi.c dma.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Application/User/X-CUBE-AI/App
    ./X-CUBE-AI/App/: app_x-cube-ai.c
    X-CUBE-AI/App/: network.c network_data.c network_data_params.c
  group Doc
    X-CUBE-AI/App/: network_generate_report.txt
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime1020_CM7_Keil.lib
software components: CMSIS:CORE 6.1.1
